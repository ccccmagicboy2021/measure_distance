# Keil uVision project test_adc.uvprojx, settings and files
target flashcode (6140001::V6.14.1::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\application\app;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\Inc;..\source;..\bsp\inc;..\application\systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group app
    ../application/app/: app.c
    ../application/systick/: systick.c
  group src
    ../source/: main.c
  group common
    ../common/: system_n32g4fr.c startup_n32g4fr.s n32g4fr_it.c
  group driver
    ../driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c n32g4fr_xfmc.c
  group debug
    ../application/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group bsp
    ../bsp/src/: delay.c log.c
target ramcode (6140001::V6.14.1::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: as above
  output: ramcode
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x20020000 size 0x4000
