# Keil uVision project distance_measure.uvprojx, settings and files
target flashcode (6160000::V6.16::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=128000000, __DEBUG,USE_DEVICE_DRIVER_LIB,_CC_ARM,DEBUG_MODE,ARM_MATH_CM4,SYSCLK_SRC=2
  c include: ..\MDK;..\driver\inc;..\driver\src;..\dsp\Include;..\common;..\HAL\inc;..\HAL\mcu_sdk;..\app\distance_measure\inc;..\app\app;..\cmsis;..\dsp_lib\Include;..\dsp_lib\dsp;..\app\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group common
    ../common/: system_n32g4fr.c startup_n32g4fr.s n32g4fr_it.c memalloc.c ringbuffer.c
  group source
    ../: main.c
    ../app/app/: app.c app.h
  group driver
    ../driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c n32g4fr_xfmc.c
  group dsp
    ../dsp/: math_fp.c
    ../dsp_lib/: arm_cortexM4lf_math.lib arm_absmax_q31.c
  group hal
    ../HAL/src/: gpio.c led.c sysclk.c timera_pwm.c usart.c adc.c
  group distance_measure
    ../app/distance_measure/src/: apfft.c comp_table.c corrcoef.c distance_measure.c filter.c hamming.c freq_linspace.c hanning_conv.c micromotion_detection.c alpha_filter.c pd_calculation.c
  group communication
    ../HAL/mcu_sdk/: mcu_api.c protocol.c system.c
  group debug
    ../app/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
