# Keil uVision project test_fft.uvprojx, settings and files
target flashcode (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MSC_CLOCK
  c include: ..\application\app;..\application\dhrystone;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\inc;..\source;..\application\fft;..\application\systick;..\application\DWTDelay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../application/app/: app.c
    ../application/systick/: systick.c
    ../application/fft/: stm32_dsp.h
    ../application/DWTDelay/: DWTDelay.c
  group src
    ../source/: main.c
  group common
    ../common/: system_stm32f10x.c startup_stm32f10x_md_vl.s
  group driver
    ../driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group debug
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
    ../application/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
  group doc
    ../: 说明.txt
  group fft
    ../application/fft/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s
target ramcode (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: ramcode
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM
  c include: ..\application\app;..\application\dhrystone;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\inc;..\source;..\application\systick;..\application\fft;..\application\DWTDelay
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x3000
