# Keil uVision project test_axf.uvprojx, settings and files
target flashcode (6140001::V6.14.1::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB,ARM_MATH_CM4,_CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,SYSTEM_GLOBAL
  c include: C:\Keil_v5\ARM\include;..\MDK;..\source;..\common;..\driver\inc;..\driver\src;..\application\rtt;..\application\tuya;..\application\adc;..\application\led;..\application\usart;..\application\timer;..\application\matlab;..\application\fifo;..\application\app;..\application\clk;..\application\shell;..\application\pwm;..\application\HardFaultHandlerMDK;..\DSP;..\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../common/: system_hc32f46x.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_utility.c
  group user
    ../application/app/: app.c
target ramcode (6140001::V6.14.1::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: as above
  output: ramcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: C:\Keil_v5\ARM\include;..\MDK;..\source;..\common;..\driver\inc;..\driver\src;..\application\rtt;..\application\tuya;..\application\adc;..\application\led;..\application\usart;..\application\timer;..\application\matlab;..\application\fifo;..\application\app;..\application\clk;..\application\shell;..\application\pwm;..\DSP;..\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x20000000 size 0x27000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
