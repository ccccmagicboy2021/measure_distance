# Keil uVision project presense_detection.uvprojx, settings and files
target presense_detection_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: presense_detection +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB,ARM_MATH_CM4,_CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --diag_suppress=186,66
  c include: ..\MDK;..\driver\inc;..\driver\src;..\dsp\Include;..\app\presense_detection\inc;..\common\inc;..\HAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ../common/src/: memalloc.c ringbuffer.c
  group source
    ./: startup_hc32f46x.s
    ../: main.c
  group driver
    ../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_adc.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_sram.c hc32f46x_timer0.c hc32f46x_usart.c hc32f46x_dmac.c hc32f46x_exint_nmi_swi.c hc32f46x_timera.c
  group dsp
    ../dsp/: arm_cortexM4lf_math.lib
  group hal
    ../common/src/: system_hc32f46x.c
    ../HAL/src/: adc.c sysclk.c test_usart.c timera_pwm.c test_gpio.c
target presense_detection_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_03_sa_interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
