# Keil uVision project test_freertos.uvprojx, settings and files
target flashcode (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_03_sa_interrupt +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB,ARM_MATH_CM4,_CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,SYSTEM_GLOBAL
  c include: C:\Keil_v5\ARM\include;..\MDK;..\source;..\common;..\driver\inc;..\driver\src;..\application\rtt;..\application\tuya;..\application\adc;..\application\led;..\application\usart;..\application\timer;..\application\matlab;..\application\fifo;..\application\app;..\application\clk;..\application\shell;..\application\pwm;..\application\HardFaultHandlerMDK;..\DSP;..\DSP\Include;..\FreeRTOS\include;..\FreeRTOS\ARM_CM4F;..\application\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../common/: system_hc32f46x.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_usart.c hc32f46x_pwc.c hc32f46x_gpio.c
  group user
    ../application/app/: app.c
    ../application/clk/: myclk.c
    ../application/usart/: myusart.c
    ../application/led/: myled.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/MemMang/: heap_4.c
    ../FreeRTOS/ARM_CM4F/: port.c
  group Segger
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
target ramcode (6140001::V6.14.1::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: as above
  output: adc_03_sa_interrupt +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: C:\Keil_v5\ARM\include;..\MDK;..\source;..\common;..\driver\inc;..\driver\src;..\application\rtt;..\application\tuya;..\application\adc;..\application\led;..\application\usart;..\application\timer;..\application\matlab;..\application\fifo;..\application\app;..\application\clk;..\application\shell;..\application\pwm;..\DSP;..\DSP\Include;..\FreeRTOS\include;..\FreeRTOS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x20000000 size 0x27000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
