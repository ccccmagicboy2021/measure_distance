# Keil uVision project lib.uvprojx, settings and files
target flashcode (6140001::V6.14.1::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F46x.1.0.5
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: add +hex (library)
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Objects\app.sct
  link misc: --diag_suppress=6305
  group src
    ./source/: add.c
