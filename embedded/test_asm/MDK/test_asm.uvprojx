# Keil uVision project test_asm.uvprojx, settings and files
target flashcode (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: PT32Z192,MSC_CLOCK
  c include: ..\application\app;..\source;..\driver\inc;..\common;..\cmsis;..\application\rtt;..\application\dhrystone;..\application\fft;..\application\DWTDelay;..\application\box;..\application\asm
  asm include: ..\common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../application/DWTDelay/: DWTDelay.c
    ../application/app/: app.cpp
    ../application/box/: box.cpp
    ../application/asm/: asm.s asm.h
  group src
    ../source/: main.cpp sys.hpp
  group common
    ../common/: pt32z192xx_it.c system_pt32z192xx.c startup_pt32z192.s
  group driver
    ../driver/src/: pt32z192xx_adc.c pt32z192xx_dsp.c pt32z192xx_gpio.c pt32z192xx_i2c.c pt32z192xx_misc.c pt32z192xx_pwm.c pt32z192xx_spi.c pt32z192xx_sys.c pt32z192xx_tim.c pt32z192xx_uart.c pt32z192xx_wdg.c pt32z192xx_qspi.c pt32z192xx_retarget.c pt32z192xx_serial.c pt32z192xx_dma.c
  group debug
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../application/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
  group fft
    ../application/fft/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h
  group doc
    ../: 说明.txt
target ramcode (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: ramcode
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: PT32Z192,VECT_TAB_SRAM,MSC_CLOCK
  c include: as above
  asm include: ..\common
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
