# Keil uVision project test_coremark.uvprojx, settings and files
target flashcode (6140001::V6.14.1::ARMCLANG)
  device: ACM32F403KEU7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\application\app;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\Inc;..\source;..\application\coremark
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group app
    ../application/app/: app.c
  group src
    ../source/: main.c
  group common
    ../common/: System_ACM32F4.c Startup_ACM32F4.s System_Accelerate.lib
  group driver
    ../driver/src/: HAL_CAN.c HAL_COMP.c HAL_CRC.c HAL_DAC.c HAL_DMA.c HAL_EFlash.c HAL_EXTI.c HAL_FSUSB.c HAL_GPIO.c HAL_I2C.c HAL_I2S.c HAL_IWDT.c HAL_LPUART.c HAL_OPA.c HAL_RTC.c HAL_SPI.c HAL_TIMER.c HAL_TIMER_EX.c HAL_UART.c HAL_UART_EX.c HAL_WDT.c HAL_AES_20210325.lib HAL_EFlash_EX.lib HAL_FAU_20210325.lib HAL_HRNG_20210325.lib HAL_SHA1_20210325.lib HAL_SHA256_20210325.lib
  group debug
    ../application/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group coremark
    ../application/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
target ramcode (6140001::V6.14.1::ARMCLANG)
  device: ACM32F403KEU7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.0
  cpu: as above
  output: ramcode
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM
  c include: ..\application\app;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\Inc;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x20000
