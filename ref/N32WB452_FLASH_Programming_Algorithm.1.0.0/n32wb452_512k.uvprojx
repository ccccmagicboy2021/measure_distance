# Keil uVision project n32wb452_512k.uvprojx, settings and files
target N32WB452 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: N32WB452
  AfterMake: cmd /c copy /Y .\Objects\N32WB452.axf ..\N32WB452.FLM
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM
  c include: src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\src\Target.lin
  link misc: --diag_suppress L6305
  group src
    ./src/: FlashDev.c FlashPrg.c
