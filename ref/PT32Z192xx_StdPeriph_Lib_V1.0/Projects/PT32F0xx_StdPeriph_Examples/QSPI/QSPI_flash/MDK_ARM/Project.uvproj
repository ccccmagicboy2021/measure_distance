# Keil uVision project Project.uvproj, settings and files
target PT32Z192 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin --output .\Out\Project.bin .\Out\Project.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: PT32Z192,USE_FULL_ASSERT,USE_STDPERIPH_DRIVER
  c include: E:\keil5.25\ARM\CMSIS\5.3.0\CMSIS\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\CMSIS\Device\PT\PT32Z192xx\Include;..\..\..\..\..\Libraries\PT32Z192xx_StdPeriph_Lib_Driver\cmsis;..\..\..\..\..\Libraries\PT32Z192xx_StdPeriph_Lib_Driver\inc;..\MDK_ARM;..\..\QSPI_flash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../: system_pt32z192xx.c
    ../../../../../Libraries/PT32Z192xx_StdPeriph_Lib_Driver/cmsis/: startup_pt32z192.s
  group User
    ../: main.c pt32z192xx_it.c
    ./: qspi_flash.c qspi_flash.h
  group Thor_Driver
    ../../../../../Libraries/PT32Z192xx_StdPeriph_Lib_Driver/src/: pt32z192xx_adc.c pt32z192xx_dsp.c pt32z192xx_gpio.c pt32z192xx_i2c.c pt32z192xx_misc.c pt32z192xx_pwm.c pt32z192xx_spi.c pt32z192xx_sys.c pt32z192xx_tim.c pt32z192xx_uart.c pt32z192xx_wdg.c pt32z192xx_qspi.c
  group Retaget
    ../../../../../Libraries/PT32Z192xx_StdPeriph_Lib_Driver/src/: pt32z192xx_retarget.c pt32z192xx_serial.c
