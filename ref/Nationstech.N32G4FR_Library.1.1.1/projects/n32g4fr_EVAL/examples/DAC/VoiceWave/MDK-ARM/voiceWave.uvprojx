# Keil uVision project voiceWave.uvprojx, settings and files
target N32G4FR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VoiceWave +hex
  AfterMake: fromelf --bin --output=.\bin\VoiceWave.bin .\Objects\VoiceWave.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,N32WB452_CPU_USE_HSI
  c include: ..\src\bsp;..\src\voice;..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group USER
    ../src/: main.c n32g4fr_it.c
  group DOC
    ../: readme.txt
  group VOICE
    ../src/bsp/: bsp_spi.c
    ../src/voice/: n32g4fr_voice_api.c n32g4fr_voice_drv.c
    ../src/: n32g4fr_w25qxx.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: n32g4fr_dac.c n32g4fr_dma.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_spi.c n32g4fr_tim.c misc.c n32g4fr_usart.c
    ../../../../bsp/src/: log.c
