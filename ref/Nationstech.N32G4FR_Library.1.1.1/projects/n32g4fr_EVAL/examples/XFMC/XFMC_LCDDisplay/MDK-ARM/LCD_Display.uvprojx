# Keil uVision project LCD_Display.uvprojx, settings and files
target N32G4FR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD_Display
  AfterMake: fromelf --bin --output=.\bin\LCD_Display.bin .\Objects\LCD_Display.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\LCD_Display.axf --output=.\bin\LCD_Display.dua
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,SYSCLK_FREQ=144000000
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group USER
    ../src/: main.c ili9341_lcd.c fonts.c pic1.c pic2.c lcd.c logo1.c logo2.c gc0308.c virtual_i2c.c dvp_demo.c n32g4fr_it.c bsp_usart.c
  group FIRMWARE
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_rcc.c n32g4fr_xfmc.c n32g4fr_gpio.c n32g4fr_usart.c
  group DOC
    ../: readme.txt
