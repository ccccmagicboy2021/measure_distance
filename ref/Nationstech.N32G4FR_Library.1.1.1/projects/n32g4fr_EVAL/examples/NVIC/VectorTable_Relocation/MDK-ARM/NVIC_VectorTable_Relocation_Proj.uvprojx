# Keil uVision project NVIC_VectorTable_Relocation_Proj.uvprojx, settings and files
target N32G4FR (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NVIC_VectorTable_Relocation_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\NVIC_VectorTable_Relocation_Proj.bin .\Objects\NVIC_VectorTable_Relocation_Proj.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_usart.c n32g4fr_wwdg.c n32g4fr_xfmc.c
  group BSP
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32g4fr_it.c
  group DOC
    ../: readme.txt
target N32G4FR_SRAM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.0
  cpu: as above
  output: NVIC_VectorTable_Relocation_Proj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER, VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20010000 size 0x8000
  memory RVCT9: RAM 0x20018000 size 0xc000
