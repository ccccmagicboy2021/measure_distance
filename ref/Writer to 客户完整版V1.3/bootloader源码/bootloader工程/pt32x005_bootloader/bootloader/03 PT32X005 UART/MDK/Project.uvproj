# Keil uVision project Project.uvproj, settings and files
target Porject (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin --output .\Out\Project.bin .\Out\Project.axf
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,Taurus01,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\PT32X005_FWLib\inc;..\..\..\Libraries\SYSTEM;..\..\..\Libraries\CMSIS;..\..\03 PT32X005 UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group System
    ../: PT32X005_it.c
    ../../../Libraries/SYSTEM/: system_PT32X005.c startup_PT32X005x.s
  group User
    ../: main.c common.c
  group PT32L03x_FWLib
    ../../../Libraries/PT32X005_FWLib/src/: PT32X005_sys.c PT32X005_uart.c PT32X005_gpio.c
  group Retarget
    ../../../Libraries/Retarget/: PT32X005_retarget.c PT32X005_serial.c
