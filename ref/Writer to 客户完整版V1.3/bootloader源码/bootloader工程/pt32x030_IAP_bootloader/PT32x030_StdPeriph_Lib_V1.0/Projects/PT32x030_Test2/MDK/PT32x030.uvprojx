# Keil uVision project PT32x030.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PT32L033C8T6 PengpaiMicroelectronics
  pack: PAI-IC.PT32X033_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PT32x032
  AfterMake: fromelf --bin --output  .\Objects\Project.bin  .\Objects\PT32x032.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,PT32x030,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\CMSIS\Device\PT32x030\Include;..\..\..\Libraries\PT32x030_StdPeriph_Lib_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\PT32x030_StdPeriph_Lib_Driver;..\..\PT32x030_Test2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group System
    ../../../Libraries/PT32x030_StdPeriph_Lib_Driver/cmsis/: startup_PT32x030.s
    ../../../Libraries/CMSIS/Device/PT32x030/Source/Templates/: system_PT32x030.c
  group StdPeriph_Driver
    ../../../Libraries/PT32x030_StdPeriph_Lib_Driver/src/: PT32x030_ana.c PT32x030_gpio.c PT32x030_misc.c PT32x030_pwm.c PT32x030_pwr.c PT32x030_sys.c PT32x030_uart.c
  group User
    ../: PT32x030_it.c pwm_test2.c common.c
  group Retarget
    ../../../Libraries/PT32x030_StdPeriph_Lib_Driver/src/: PT32x030_retarget.c PT32x030_serial.c
