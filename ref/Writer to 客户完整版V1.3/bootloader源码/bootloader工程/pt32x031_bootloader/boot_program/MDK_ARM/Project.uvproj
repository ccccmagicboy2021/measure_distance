# Keil uVision project Project.uvproj, settings and files
target Pangu_FPGA (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin --output .\Out\Project.bin .\Out\Project.axf
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,PT32F031
  c include: ..\..\Lib\inc;..\..\Lib\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../../Lib/startup/arm/: startup_pangu01.s
  group CMSIS
    ../../Lib/src/: system_pangu01.c
  group User
    ../: main.c Pangu01_it.c BspTime.c common.c download.c ymodem.c
  group Pangu01_Driver
    ../../Lib/src/: pangu01_ana.c pangu01_crc.c pangu01_flash.c pangu01_gpio.c pangu01_i2c.c pangu01_spi.c pangu01_sys.c pangu01_uart.c pangu01_wdt.c
  group Retaget
    ../../Lib/src/: pangu01_serial.c pangu01_retarget.c
