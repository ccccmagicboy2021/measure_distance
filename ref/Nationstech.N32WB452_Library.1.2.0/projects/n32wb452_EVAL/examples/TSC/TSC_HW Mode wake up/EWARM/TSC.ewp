# IAR project TSC.ewp, settings and files
configuration N32WB452 (ARM, debug)
  General.OGChipSelectEditMenu: N32WB452LE Nations N32WB452LE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32WB452; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/n32wb452_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32WB452\N32WB452xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bsp
    ../src/: bsp_gpio.c bsp_tsc.c bsp_usart.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group DOC
    ../: readme.txt
  group Driver
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_dbg.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_tim.c n32wb452_tsc.c n32wb452_usart.c
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452_EWARM.s
  group User
    ../src/: delay.c main.c n32wb452_it.c
