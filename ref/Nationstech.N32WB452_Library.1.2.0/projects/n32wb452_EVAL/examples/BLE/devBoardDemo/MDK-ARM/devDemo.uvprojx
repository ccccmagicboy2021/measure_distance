# Keil uVision project devDemo.uvprojx, settings and files
target N32WB452_BLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ble_transfer +hex
  c flags: uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: N32WB452, USE_STDPERIPH_DRIVER,N32WB452_BT_API,BD_RTC_USE_LSI
  c misc: --wchar32
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\btapi\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\profile\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\platform\inc;..\..\..\..\..\..\firmware\n32wb452_ble_driver\;..\inc;..\src\bsp;..\src\lcd;..\src\gsensor;..\src\lcd\Fonts;..\src\hdc2010;..\src\api\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\ble.sct
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_exti.c n32wb452_gpio.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_tim.c n32wb452_usart.c n32wb452_spi.c n32wb452_adc.c n32wb452_tsc.c n32wb452_dma.c n32wb452_dbg.c n32wb452_rtc.c n32wb452_bkp.c n32wb452_i2c.c n32wb452_flash.c
  group USER
    ../src/: main.c n32wb452_it.c
    ../../../../../../firmware/n32wb452_std_periph_driver/inc/: n32xx_tsc_alg_api.h n32xx_tsc_alg_api.lib
    ../src/api/src/: n32wb452_rtc_hal.c n32wb452_touch_app.c n32wb452_sram_scatter_init.c
    ../../../../bsp/src/: log.c
  group BSP
    ../src/bsp/: bsp_spi.c bsp_adc.c bsp_timer.c
  group LCD
    ../src/lcd/: lcd_drv.c lcd_gui.c lcd_display.c
    ../src/lcd/Fonts/: font24.c
  group GSENSOR
    ../src/gsensor/: gsensor.c qma_i2c_drv.c
  group HDC2010
    ../src/hdc2010/: hdc_i2c_drv.c HDC2010.c
  group BT_API
    ../src/api/src/: n32wb452_data_fifo.c
    ../../../../../../firmware/n32wb452_ble_driver/: host.lib n32wb452_ble.lib n32wb452_ble_api.c
  group BT_PROFILE
    ../../../../../../firmware/n32wb452_ble_driver/profile/: app.c app_batt.c app_sec.c app_task.c app_user.c bass.c bass_task.c prf.c prf_utils.c user.c user_task.c
  group BT_PLATFORM
    ../../../../../../firmware/n32wb452_ble_driver/platform/: Eif_debug.c Eif_flash.c Eif_timer.c Interface.c
