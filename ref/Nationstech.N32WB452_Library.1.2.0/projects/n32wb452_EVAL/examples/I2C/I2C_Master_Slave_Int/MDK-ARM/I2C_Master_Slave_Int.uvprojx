# Keil uVision project I2C_Master_Slave_Int.uvprojx, settings and files
target N32WB452 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32WB452REQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_Master_Slave_Int_Project +hex
  AfterMake: fromelf --bin --output=.\bin\I2C_Master_Slave_Int_Project.bin .\Objects\I2C_Master_Slave_Int_Project.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\I2C_Master_Slave_Int_Project.axf --output=.\bin\I2C_Master_Slave_Int_Project.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_usart.c n32wb452_rcc.c
  group USER
    ../src/: main.c n32wb452_it.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
